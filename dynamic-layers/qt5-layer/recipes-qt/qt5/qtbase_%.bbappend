
PACKAGECONFIG:append = " examples libinput linuxfb fontconfig sql-sqlite no-opengl"
PACKAGECONFIG:remove = " icu tests gl gles2 eglfs kms gbm"
