IMAGE_INSTALL_append_imx7d-pico = " \
	packagegroup-qt5 \
"
