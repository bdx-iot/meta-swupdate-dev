# libssh2 is required if we want
# to use scp/sftp
PACKAGECONFIG:append = " libssh2"
