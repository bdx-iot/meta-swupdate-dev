FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

dirs755:append = " /data"
