OS_RELEASE_FIELDS:append = " HOME_URL BDX_PRODUCT"
HOME_URL = "https://github.com/bdx-iot/meta-swupdate-dev"
BDX_PRODUCT = "SWUforwarder"
